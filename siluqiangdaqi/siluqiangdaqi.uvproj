# Keil uVision project siluqiangdaqi.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: siluqiangdaqi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user_code\Beep;.\user_code\Key;.\user_code\Public;.\user_code\Smg;.\user_code\Time
  group Source Group 1
    ./: STARTUP.A51 siluqiangdaqi.c
  group Key
    ./user_code/Key/: key.c
  group Smg
    ./user_code/Smg/: smg.c
  group Time
    ./user_code/Time/: time.c
  group Public
    ./user_code/Public/: public.c
  group Beep
    ./user_code/Beep/: beep.c
